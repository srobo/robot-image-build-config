OS_RELEASE_FIELDS = "NAME PRETTY_NAME ID VERSION VERSION_ID HOME_URL DOCUMENTATION_URL ANSI_COLOR"

NAME = "Student Robotics OS"
PRETTY_NAME = "${NAME} ${VERSION_ID}"
ID = "srobo"
VERSION = "${VERSION_ID}"
VERSION_ID = "${SROBO_VERSION}"
HOME_URL = "http://studentrobotics.org/"
DOCUMENTATION_URL = "http://studentrobotics.org/docs"
ANSI_COLOR = "0;38;2;50;112;237"

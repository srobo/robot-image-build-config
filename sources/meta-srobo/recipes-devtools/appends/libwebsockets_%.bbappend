EXTRA_OECMAKE += " -DLWS_WITH_EXTERNAL_POLL=ON "
